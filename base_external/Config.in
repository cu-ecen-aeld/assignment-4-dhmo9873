## base_external/Config.in
```kconfig
menu "Project Base Packages"
source "$BR2_EXTERNAL_PROJECT_BASE_PATH/package/Config.in"
endmenu
```
